# Keil uVision project ToF_STM_Initialization.uvprojx, settings and files
target src (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ToF_STM +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\inc;.\CMSIS;.\startup
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./: main.c
    ./src/: misc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_sdio.c stm32f10x_usart.c stm32f10x_rcc.c assert_failed.c isl29501.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group inc
    ./inc/: core_cm3.h stm32f10x.h system_stm32f10x.h stm32f10x_dma.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_usart.h stm32f10x_assert.h stm32f10x_rcc.h stm32f10x_conf.h isl29501.h
  group startup
    ./startup/: startup_stm32f10x_md.s
